<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>3.7e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ipaddr</value></param>
<param><key>value</key><value>"192.168.1.100"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>port</value></param>
<param><key>value</key><value>1001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(1e6)</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>hello/rx-rp.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>hello/code-l10000-b10-000000.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>TX Power</value></param>
<param><key>const</key><value>.01</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>red_pitaya_sink</key>
<param><key>id</key><value>red_pitaya_sink_0</value></param>
<param><key>addr</key><value>ipaddr</value></param>
<param><key>freq</key><value>fc</value></param>
<param><key>corr</key><value>0</value></param>
<param><key>ptt</key><value>False</value></param>
<param><key>port</key><value>port</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>red_pitaya_source</key>
<param><key>id</key><value>red_pitaya_source_0</value></param>
<param><key>addr</key><value>ipaddr</value></param>
<param><key>freq</key><value>fc</value></param>
<param><key>corr</key><value>0</value></param>
<param><key>port</key><value>port</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>red_pitaya_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>red_pitaya_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
